# Keil uVision project HUST RM .uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F405OEYx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HUST RM +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx, MATH_CM4,__FPU_PRESENT=1,__FPU_USED =1, ARM_MATH_CM4, __CC_ARM
  c include: ..\User;..\Mylib;..\Library\CMSIS;..\Library\inc;..\Library\src;..\Task;..\Mylib;..\FreeRTOS\src;..\FreeRTOS\port\MemMang;..\FreeRTOS\port\RVDS\ARM_CM4F;..\FreeRTOS\include;..\Hardware;..\Algorithm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group FreeRTOS/Port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group FreeRTOS/Src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Library
    ../Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_spi.c
    ../Library/CMSIS/: startup_stm32f40_41xxx.s
    ../Library/inc/: stm32f4xx_spi.h
  group Mylib
    ../Mylib/: algorithmOfCRC.c tim.c
  group Task
    ../Task/: Start_Task.c Start_Task.h
  group Hardware
    ../Hardware/: usart1.c usart1.h wifi.c wifi.h spi.c spi.h lcd.c lcd.h SD.c SD.h key.c key.h
  group User
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c FreeRTOSConfig.h main.h gpio.h
